<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LM_gemini_gpt.ewp</path>
  </project>
  <batchBuild/>
</workspace>


