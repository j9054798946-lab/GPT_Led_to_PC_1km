# IAR project LM_gemini_gpt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM7S256 Atmel AT91SAM7S256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: at91sam7s256; flash; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\IAR_projects\IAR_AI\Lmarena\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  group (top)
    ./: AT91SAM7S256.h flash.icf main.c my_dac.c my_dac.h startup.s
    ../../C/: main.ENU.projtempl
